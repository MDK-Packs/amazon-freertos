# Keil uVision project aws_demos.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54101J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x02000000,0x00010000) IRAM2(0x02010000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_demos
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CPU_LPC54018 CPU_LPC54018JET180=1 BOARD_USE_VIRTUALCOM USB_STACK_FREERTOS USB_DEVICE_CONFIG_LPCIP3511HS=1 USB_STACK_USE_DEDICATED_RAM=1 USE_RTOS=1 FSL_RTOS_FREE_RTOS A_LITTLE_ENDIAN
  c misc: --diag_suppress=47,66,1295
  c include: ..\common\config_files;..\common\application_code\nxp_code;..\..\..\common\include;..\..\..\..\lib\include;..\..\..\..\lib\include\private;..\..\..\..\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\..\..\lib\third_party\jsmn;..\..\..\..\lib\third_party\mbedtls\include;..\..\..\..\lib\third_party\pkcs11;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\drivers;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\drivers\common;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\debug_console;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\log;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\io;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\str;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\usb\device;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\usb\include;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\usb\osa;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\include;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\include\AR6002;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\include\AR6002\hw2.0\hw;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\include\AR6002\hw4.0\hw;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\common_src\include;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\common_src\stack_common;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\common_src\hcd;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\common_src\wmi;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\custom_src\include;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\custom_src\stack_custom;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\drivers\flexcomm_freertos;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\env\freertos;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\boards\clickbrd_tread\freertos;..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\boards\clickbrd_tread\freertos\gt202
  asm define: MXL12835F
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  scatter file: ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\arm\LPC54018_ram.scf
  group app
    ../common/application_code/: main.c
    ../common/application_code/nxp_code/: board.c clock_config.c pin_mux.c wlan_qca400x.c wlan_qcom.c
  group app_credentials
    ../../../common/include/: aws_clientcredential.h aws_clientcredential_keys.h
  group app_config
    ../common/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group app_common
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../common/tcp/: aws_tcp_echo_client_single_task.c
  group lib_FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group lib_aws
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
    ../../../../lib/crypto/: aws_crypto.c
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
    ../../../../lib/pkcs11/portable/nxp/lpc54018_iot_module/: hw_poll.c pkcs11.c
    ../../../../lib/secure_sockets/portable/nxp/lpc54018_iot_module/: aws_secure_sockets.c
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
    ../../../../lib/tls/: aws_tls.c
    ../../../../lib/utils/: aws_system_init.c
    ../../../../lib/wifi/portable/nxp/lpc54018_iot_module/: aws_wifi.c
  group lib_jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
  group lib_mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib_LPC54018_power
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/arm/: keil_lib_power.lib
  group lib_LPC54018_drivers
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_emc.c fsl_enet.c fsl_flexcomm.c fsl_gpio.c fsl_i2c.c fsl_i2s.c fsl_inputmux.c fsl_pint.c fsl_power.c fsl_reset.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_usart.c mflash_drv.c mflash_file.c
  group lib_LPC54018_utilities
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/: fsl_assert.c fsl_debug_console.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_descriptor.c virtual_com.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/io/: fsl_io.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/log/: fsl_log.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/str/: fsl_str.c
  group lib_LPC54018_middleware_usb
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/osa/: usb_osa_freertos.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/device/: usb_device_dci.c usb_device_lpcip3511.c
  group lib_LPC54018_middleware_wifi
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/bmi/: bmi.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/hcd/: spi_hcd.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/hw_interface/: hw_api.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_legacy.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/util/: util.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/wmi/: wmi.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/env/freertos/: wifi_env.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/boards/clickbrd_tread/freertos/: wifi_shield.c
  group lib_LPC54018_startup
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/: system_LPC54018.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/arm/: startup_LPC54018.s
