# Keil uVision project aws_demos.uvprojx, settings and files
target Debug (6090000::V6.9::.\ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_demos
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __GNUC__ USE_HAL_DRIVER STM32L475xx MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h ENABLE_IOT_INFO ENABLE_IOT_ERROR SENSOR RFU
  c misc: -Wno-format -Wno-macro-redefined -Wno-absolute-value
  c include: ..\common\config_files;..\common\application_code;..\common\application_code\st_code;..\..\..\common\include;..\..\..\..\lib\include;..\..\..\..\lib\include\private;..\..\..\..\lib\FreeRTOS\portable\GCC\ARM_CM4F;..\..\..\..\lib\third_party\jsmn;..\..\..\..\lib\third_party\mbedtls\include;..\..\..\..\lib\third_party\pkcs11;..\..\..\..\lib\third_party\tinycbor;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\CMSIS\Include;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\STM32L4xx_HAL_Driver\Inc;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\B-L475E-IOT01;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\Common;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\es_wifi;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\hts221;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\lis3mdl;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\lps22hb;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\lsm6dsl;..\..\..\..\lib\third_party\mcu_vendor\st\stm32l475_discovery\BSP\Components\vl53l0x
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: aws_demos.sct
  group app
    ../common/application_code/: main.c
    ../common/application_code/st_code/: entropy_hardware_poll.c es_wifi_io.c flash_l4.c stm32l4xx_hal_msp.c stm32l4xx_it.c vl53l0x_platform.c vl53l0x_proximity.c
    ./: retarget_io.c startup_stm32l475xx.s
  group app_credentials
    ../../../common/include/: aws_clientcredential.h aws_clientcredential_keys.h
  group app_config
    ../common/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group app_common
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../common/tcp/: aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
  group lib_FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_5.c
    ../../../../lib/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group lib_aws
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
    ../../../../lib/crypto/: aws_crypto.c
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
    ../../../../lib/pkcs11/portable/st/stm32l475_discovery/: pkcs11.c
    ../../../../lib/secure_sockets/portable/st/stm32l475_discovery/: aws_secure_sockets.c
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
    ../../../../lib/tls/: aws_tls.c
    ../../../../lib/utils/: aws_system_init.c
    ../../../../lib/wifi/portable/st/stm32l475_discovery/: aws_wifi.c
  group lib_jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
  group lib_mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib_tinycbor
    ../../../../lib/third_party/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
  group lib_stm32l475_discovery_BSP
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_qspi.c stm32l475e_iot01_tsensor.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/es_wifi/: es_wifi.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/hts221/: hts221.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/lps22hb/: lps22hb.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/lsm6dsl/: lsm6dsl.c
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group lib_STM32L4xx_HAL_Driver
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/STM32L4xx_HAL_Driver/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group lib_STM32L4xx_CMSIS
    ../../../../lib/third_party/mcu_vendor/st/stm32l475_discovery/CMSIS/: system_stm32l4xx.c
target Release (6090000::V6.9::.\ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: aws_demos
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -Wno-format -Wno-macro-redefined -Wno-absolute-value
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: aws_demos.sct
